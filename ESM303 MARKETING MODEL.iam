# Autodesk Inventor assembly: ESM303 MARKETING MODEL
## iProperties
Created: 2016-05
Part Number: ESM303 MARKETING MODEL
Document SubType Name: Assembly
Designer: ML
Author: ML
